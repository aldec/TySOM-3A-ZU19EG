SRC_URI_append_tysom-3-zu7ev = " \
            file://boot.cmd.sd.zynqmp \
            "
            
SRC_URI_append_tysom-3a-zu19eg = " \
            file://boot.cmd.sd.zynqmp \
            "            
FILESEXTRAPATHS_prepend := "${THISDIR}/u-boot-zynq-scr/:"
