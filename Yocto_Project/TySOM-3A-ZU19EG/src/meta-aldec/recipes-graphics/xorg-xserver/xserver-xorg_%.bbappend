PACKAGECONFIG[glamor] = "--disable-glamor"
